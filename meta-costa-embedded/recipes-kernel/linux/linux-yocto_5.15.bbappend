FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://smp.cfg"
