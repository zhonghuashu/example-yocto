addtask build